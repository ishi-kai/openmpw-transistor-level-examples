v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/ipin.sym} 220 -280 0 0 {name=p1 lab=clk}
C {devices/ipin.sym} 220 -300 0 0 {name=p5 lab=rst_n}
C {devices/ipin.sym} 220 -240 0 0 {name=p7 lab=ena}
C {devices/opin.sym} 600 -120 0 0 {name=p6 lab=DIGITAL_OUT[0]}
C {devices/ipin.sym} 220 -360 0 0 {name=p8 lab=VPWR}
C {devices/ipin.sym} 220 -340 0 0 {name=p9 lab=VGND}
C {devices/opin.sym} 600 -240 0 0 {name=p10 lab=DIGITAL_OUT[6]}
C {devices/opin.sym} 600 -140 0 0 {name=p12 lab=DIGITAL_OUT[1]}
C {devices/opin.sym} 600 -160 0 0 {name=p18 lab=DIGITAL_OUT[2]}
C {devices/opin.sym} 600 -180 0 0 {name=p19 lab=DIGITAL_OUT[3]}
C {devices/opin.sym} 600 -200 0 0 {name=p20 lab=DIGITAL_OUT[4]}
C {devices/opin.sym} 600 -220 0 0 {name=p21 lab=DIGITAL_OUT[5]}
C {devices/opin.sym} 600 -260 0 0 {name=p2 lab=DIGITAL_OUT[7]}
